Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-SSDX1S.IFC
Time: 2022-01-04T07:43:43
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: A0127-0068_HK-MSD_®ø¬r¾÷500cc¥~´ß
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: A0127-0069_HK-MSD_®øËH¾÷500cc©³®y_20200721
In: Default Storey
PredefinedType: ELEMENT; Material: ABS
